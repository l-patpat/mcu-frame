# Keil uVision project frame.uvproj, settings and files
target frame (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: frame +hex
  c define: STM32F10X_HD
  c include: .\CM3;..\..\frame
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/: main.c operation.c uart.c
    ../../frame/: task.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group CM3
    ./CM3/: core_cm3.c system_stm32f10x.c
