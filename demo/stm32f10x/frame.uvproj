# Keil uVision project frame.uvproj, settings and files
target frame (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: frame +hex
  c flags: Optim=4
  c define: STM32F10X_HD
  c include: .\src;.\CM3;.\Driver;..\..\frame
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/: main.c uart.c debug.c spi.c
    ../../frame/: task.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group Driver
    ./Driver/: SerialFlash.c
  group CM3
    ./CM3/: core_cm3.c STM32_Init.c
target frame_debug (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: frame +hex
  c flags: Optim=4
  c define: STM32F10X_HD, _DEBUG
  c include: .\src;.\CM3;.\Driver;..\..\frame
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
